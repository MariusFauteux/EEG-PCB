# Repository MariusFauteux/EEG-PCB (continued)

## KiCad design hardware/EEG_RevC.kicad_pcb (continued)

Board: 4 copper layers, 381 parts (0 on the bottom side), 235 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3

File hardware/bom.csv (part):

Ref,Value,Footprint,Manufacturer,MPN,Description,DNP,Population
C1,220p C0G 5% 50V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H221JA16D,Capacitor 220 pF 5 % 50 V C0G 0603,no,FIT
C2,220p C0G 5% 50V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H221JA16D,Capacitor 220 pF 5 % 50 V C0G 0603,no,FIT
C3,220p C0G 5% 50V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H221JA16D,Capacitor 220 pF 5 % 50 V C0G 0603,no,FIT
C4,220p C0G 5% 50V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H221JA16D,Capacitor 220 pF 5 % 50 V C0G 0603,no,FIT
C5,220p C0G 5% 50V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H221JA16D,Capacitor 220 pF 5 % 50 V C0G 0603,no,FIT
C6,220p C0G 5% 50V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H221JA16D,Capacitor 220 pF 5 % 50 V C0G 0603,no,FIT
C7,220p C0G 5% 50V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H221JA16D,Capacitor 220 pF 5 % 50 V C0G 0603,no,FIT
C8,220p C0G 5% 50V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H221JA16D,Capacitor 220 pF 5 % 50 V C0G 0603,no,FIT
C100,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C101,100n 16V X7R,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C102,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C103,100n 16V X7R,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C104,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C105,100n 16V X7R,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C106,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C107,100n 16V X7R,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C108,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C109,100n 16V X7R,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C110,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C111,100n 16V X7R,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C112,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C113,100n 16V X7R,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C114,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C115,100n 16V X7R,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C116,100u 10V tantalum,Capacitor_Tantalum_SMD:CP_EIA-7343-31_Kemet-D,KEMET,T491D107K010AT,Capacitor tantalum 100 uF 10 V 10 % case D 7343-31,no,FIT
C117,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C118,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C119,100n 16V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C120,1u 10V X7R,Capacitor_SMD:C_0805_2012Metric,Murata,GCM21BR71E105KA56L,Capacitor 1 uF 10 % 25 V X7R 0805,no,FIT
C121,22u 10V X7R,Capacitor_SMD:C_1210_3225Metric,Murata,GRM32ER71E226KE15L,Capacitor 22 uF 10 % 25 V X7R 1210,no,FIT
C122,100n 16V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C123,10u 10V X7R,Capacitor_SMD:C_1206_3216Metric,Murata,GRM31CR71E106KA12L,Capacitor 10 uF 10 % 25 V X7R 1206,no,FIT
C124,10u 10V X7R,Capacitor_SMD:C_1206_3216Metric,Murata,GRM31CR71E106KA12L,Capacitor 10 uF 10 % 25 V X7R 1206,no,FIT
C125,10u 10V X7R,Capacitor_SMD:C_1206_3216Metric,Murata,GRM31CR71E106KA12L,Capacitor 10 uF 10 % 25 V X7R 1206,no,FIT
C201,4.7u 16V X7R 0805 (CSET),Capacitor_SMD:C_0805_2012Metric,Murata,GRM21BR71C475KE51L,Capacitor 4.7 uF 10 % 16 V X7R 0805,no,FIT
C202,10u 25V X7R 1206 (SYS),Capacitor_SMD:C_1206_3216Metric,Murata,GRM31CR71E106KA12L,Capacitor 10 uF 10 % 25 V X7R 1206,no,FIT
C203,22u 25V X7R 1210,Capacitor_SMD:C_1210_3225Metric,Murata,GRM32ER71E226KE15L,Capacitor 22 uF 10 % 25 V X7R 1210,no,FIT
C204,22u 25V X7R 1210,Capacitor_SMD:C_1210_3225Metric,Murata,GRM32ER71E226KE15L,Capacitor 22 uF 10 % 25 V X7R 1210,no,FIT
C210,100n bypass,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C211,100n C0G 5% 50V delay,Capacitor_SMD:C_1206_3216Metric,Murata,GRM31C5C1H104JA01L,Capacitor 100 nF 5 % 50 V C0G 1206,no,FIT
C212,100n bypass,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C213,100n C0G 5% 50V delay,Capacitor_SMD:C_1206_3216Metric,Murata,GRM31C5C1H104JA01L,Capacitor 100 nF 5 % 50 V C0G 1206,no,FIT
C214,100n bypass,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C215,10n C0G 5% 50V delay,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H103JA16D,Capacitor 10 nF 5 % 50 V C0G 0603,no,FIT
C216,100n bypass,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C217,10n C0G 5% 50V delay,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H103JA16D,Capacitor 10 nF 5 % 50 V C0G 0603,no,FIT
C218,100n bypass,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C219,10n C0G 5% 50V delay,Capacitor_SMD:C_0603_1608Metric,Murata,GCM1885C1H103JA16D,Capacitor 10 nF 5 % 50 V C0G 0603,no,FIT
C226,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C227,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C228,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C230,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C231,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C232,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C233,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C234,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C235,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C240,10u 25V X7R 1206 (SYS),Capacitor_SMD:C_1206_3216Metric,Murata,GRM31CR71E106KA12L,Capacitor 10 uF 10 % 25 V X7R 1206,no,FIT
C241,22u 25V X7R 1210,Capacitor_SMD:C_1210_3225Metric,Murata,GRM32ER71E226KE15L,Capacitor 22 uF 10 % 25 V X7R 1210,no,FIT
C242,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C300,10u 25V X7R 1206,Capacitor_SMD:C_1206_3216Metric,Murata,GRM31CR71E106KA12L,Capacitor 10 uF 10 % 25 V X7R 1206,no,FIT
C301,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C302,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C303,100n 10V,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C310,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C311,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
C312,100n,Capacitor_SMD:C_0603_1608Metric,Murata,GCM188R71H104KA57D,Capacitor 100 nF 10 % 50 V X7R 0603,no,FIT
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